DESCRIPTION = "REC testing recipe. Does nothing, yust says something..."
LICENSE = "MIT"

inherit core-image
